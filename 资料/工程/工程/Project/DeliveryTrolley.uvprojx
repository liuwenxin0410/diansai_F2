# Keil uVision project DeliveryTrolley.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DeliveryTrolley
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\Users;..\Hardware\sys;..\Hardware\encoder;..\Hardware\Infrared;..\Hardware\led;..\Hardware\motor;..\Hardware\tim1;..\Hardware\usart1;..\Hardware\usart2;..\Hardware\usart3;..\Hardware\nvic;..\Hardware\pid;..\Hardware\timer3;..\Hardware\systick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group USERS
    ../Users/: main.c stm32f10x_it.c myconfig.c myconfig.h
  group HARDWARE
    ../Hardware/sys/: sys.c
    ../Hardware/led/: led.c
    ../Hardware/nvic/: nvic.c
    ../Hardware/Infrared/: infrared.c
    ../Hardware/tim1/: tim1.c
    ../Hardware/encoder/: encoder.c
    ../Hardware/motor/: motor.c
    ../Hardware/usart1/: usart1.c
    ../Hardware/usart2/: usart2.c
    ../Hardware/usart3/: usart3.c
    ../Hardware/timer3/: tim3.c
    ../Hardware/systick/: systick.c
  group PID
    ../Hardware/pid/: pid.c
  group DOC
    ../Doc/: bsp_xx.c bsp_xx.h Read me.txt
